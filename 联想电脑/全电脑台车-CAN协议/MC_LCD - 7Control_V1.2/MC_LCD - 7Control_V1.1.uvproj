# Keil uVision project MC_LCD - 7Control_V1.1.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CAN
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./common/src/: startup_LPC17xx.s
  group System Code
    ./common/src/: system_LPC17xx.c
  group Source Code
    ./Src/: App_sys.c timer.c can.c main.c CanOpen.c adc.c GPIO.c i2c.c uart.c App_IO.c App_Bus.c Task.c pwm.c App_DGUS.c App_uart.c App_comm.c
  group Documentation
    ./: Abstract.txt
    ./Src/: config.h
  group USER CODE
    ./Src/: App_KEY.c App_usr.c App_lcd.c function.c Arm200A_Kine.c Arm200A_Store.c ScanCycle.c
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MC_LCD - 7Control_V +hex
  AfterMake: fromelf.exe --bincombined --bincombined_base=0x000 --bincombined_padding=1,0 --output="$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\common\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
